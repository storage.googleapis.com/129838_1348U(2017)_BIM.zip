Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-15T13:59:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 15 13:59:56 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{474695DD-3DB8-4CCC-AFA7-1B943D8A0EB5}\ifc * Database version: 5507 * Database creation date: Fri Mar 15 13:59:55 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 15 13:59:56 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 15 13:59:56 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1348U Bath and shower faucet with shower set, 1348U:1348U Bath and shower faucet with shower set:346423
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 203.042 mm; FaucetNominalHeight: 77.4739 mm; FaucetNominalWidth: 282 mm; HandShowerNominalDepth: 138 mm; HandShowerNominalHeight: 701 mm; HandShowerNominalWidth: 220 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1348U; ConvergoRefNr: 0087-1803-0018-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 13/03/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150079238; EN Standard: EN 1111; Noise Class: I (ISO 3822) Oras lab.
Type - Identity Data(Type) - Catalog Drawing URL: http://static.oras.com/catdrw/1348U; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/1348U; FDV Document URL: http://www.oras.com/datasheet/1348U/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1348U; Group: Bath and shower faucets; Long Marketing: Thermostatic bath and shower faucet that reacts quickly and precisely to the changes of incoming water temperature and keeps the water temperature as selected. Temperature limiter in the handle. Spout with diverter and aerator. EcoFlow control. Includes eccentric unions and cover plates. Non-return valves and litter filters are included. Oras Apollo shower set, Oras nr 544, including hand shower with three spray options including EcoFlow control, adjustable max. 720 mm shower rail, 1750 mm shower hose and a soap tray; Manufacturer: Oras; Model: 1348U Bath and shower faucet with shower set; Name_en: 1348U Bath and shower faucet with shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 959 x 203 x 108; Package Weight: n/a; Product Code: 1348U; Product Datasheet: http://www.oras.com/datasheet/1348U/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1348U; Product URL: http://static.oras.com/1348U; Type Name: 1348U Bath and shower faucet with shower set
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection: Covered eccentric unions; Diverter: Push diverter; Eco Flow At 300kPa: 0.00565035 m3/s; Flow: EcoFlow control; Flow Rate At 300kPa: 0.0116538 m3/s; Installation and Maintenance: http://static.oras.com/manual/1348U; Installation Type: Wall-mounted; Lever Handle: Temperature control handle, flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Litter filter(s);Non-return valve(s); Shower Parts: Shower rail;Hand shower;Shower set;Shower hose; Spare Parts: http://static.oras.com/sp/1348U; Spout Type: Fixed spout; Temperature: Temperature limiter;Temperature fixable
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1348U; Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1348U; Name: 1348U Bath and shower faucet with shower set; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 282x203x77.5 mm / Shower: 220x138x701 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1348U; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1348U Bath and shower faucet with shower set
Constraints - DistanceX-axis: 300 mm; DistanceY-axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.378414 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.02576 m3
Identity Data - Mark: 24
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1348U: 1348U Bath and shower faucet with shower set; Family and Type: 1348U: 1348U Bath and shower faucet with shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1348U: 1348U Bath and shower faucet with shower set; Type Id: 1348U: 1348U Bath and shower faucet with shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
